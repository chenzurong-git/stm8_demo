# IAR project stm8_demo.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S207MB STM8S207MB
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S207
  ICCSTM8.CCIncludePath2: ..\APP; ..\BSP; ..\Lib\inc; ..\Lib\src; ..\Lib; ..\BSP\uart; ..\BSP\sys; ..\BSP\clk; ..\BSP\timer; ..\Min_Task_OS\inc; ..\APP\msh
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: stm8_demo.hex
  ILINK.IlinkOutputFile: stm8_demo.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group APP
    ../APP/: app_task.c app_task.h main.c
  group APP/MSH
    ../APP/msh/: msh.c msh.h msh_task.c msh_task.h
  group BSP
    ../BSP/clk/: bsp_clk.c
    ../BSP/sys/: bsp_sys.c bsp_sys_delay.c
    ../BSP/uart/: bsp_uart.c
    ../BSP/timer/: sys_timer.c
  group LIB
    ../Lib/src/: stm8s_clk.c stm8s_gpio.c stm8s_it.c stm8s_tim4.c stm8s_uart1.c
  group MTOS
    ../Min_Task_OS/src/: mtos_list.c mtos_task.c
